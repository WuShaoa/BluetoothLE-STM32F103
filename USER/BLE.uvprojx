# Keil uVision project BLE.uvprojx, settings and files
target BLE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LORA +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\USART3;..\HARDWARE\TIMER;..\BLE;..\MyCode\ADC;..\MyCode\FSR;..\MyCode\HX711;..\MyCode\KEY;..\MyCode\led;..\MyCode\TFT;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\IMU901;..\HARDWARE\USART3;..\USER;..\HARDWARE\USART2;..\HARDWARE\LED;..\CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/IMU901/: imu901.c ringbuffer.c
    ../HARDWARE/USART2/: usart2.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
  group BLE
    ../BLE/: ble_uart.c ble_app.c ble_cfg.h
  group README
    ../: README.TXT
  group MYCODE
    ../MyCode/ADC/: adc.c
    ../MyCode/FSR/: FSR.c
    ../MyCode/HX711/: HX711.c
    ../MyCode/led/: LED.c
    ../MyCode/TFT/: GUI.c Lcd_Driver.c TFT_demo.c
